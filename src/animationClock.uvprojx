# Keil uVision project animationClock.uvprojx, settings and files
target STM32F103 Flash (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: animation_clock_v0.1b +hex
  c flags: Optim=4 oTime=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: USE_GRAPHICS_VIRTUAL_BUFFER, USE_GRAPHICS_FORMAT_RGB_565, USE_GRAPHICS_FORMAT_BW_1_V
  c include: .\mane;.\i2cm;.\AM2320;.\hdc1080;.\LIB\ds18x20;.\LIB\one_wire;.\WEB;.\USART;.\LIB;.\BMP280
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group main
    ./mane/: main.c clock_gui.c clock_gui.h
  group utils
    ./LIB/utils/: delay.h delay.c utils.h
  group tft
    ./LIB/tft9341/: tft9341.c tft9341_cache.c tft9341.h tft9341_cache.h tft9341_cache_vbuf.h
  group grafics
    ./mane/: font_droid_sans_mono_8x16_utf8.h
    ./LIB/graphics/: painter.h graphics.h graphics.c painter.c font.c font.h font_5x8_utf8.h font_10x16_utf8.h font_ascii_5x8.h graphics_inlines.h point.h rect.h
  group dma
    ./LIB/dma/: dma.c dma.h
  group defs
    ./LIB/defs/: defs.h
  group bits
    ./LIB/bits/: bits.h
  group future
    ./LIB/future/: future.c future.h
  group mutex
    ./LIB/mutex/: mutex.h mutex.c
  group fixet
    ./LIB/fixed/: fixed.h fixed16.h fixed32.h
  group errors
    ./LIB/errors/: errors.h
  group gui
    ./LIB/gui/: gui.c gui_anim_bitmap.c gui_object.c gui_widget.c gui.h gui_anim_bitmap.h gui_button.h gui_checkbox.h gui_event.h gui_label.h gui_number_label.h gui_object.h gui_radiobutton.h gui_spinbox.h gui_widget.h
  group counter
    ./LIB/counter/: counter.c counter.h
  group list
    ./LIB/list/: list.h list.c
  group usart
    ./LIB/usart/: usart_buf.h usart_bus.h
    ./LIB/buffer/: circular_buffer.h buffer_defs.h buffer.h
  group rtc
    ./LIB/rtc/: rtc.c rtc.h
  group i2cm
    ./i2cm/: i2cm.c i2cm.h
  group AM2320
    ./AM2320/: AM2320.h AM2320.c
  group spi
    ./LIB/spi/: spi.c spi.h
  group ds18b20
    ./LIB/ds18x20/: ds18x20.c ds18x20.h
  group one_wire
    ./LIB/one_wire/: one_wire.h one_wire.c
  group uart
    ./USART/: usart.h usart.c
  group input
    ./LIB/input/: key_input.c key_input.h keys.h
  group BMP280
    ./BMP280/: BME280.c BME280.h
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.6.0, Device:StdPeriph Drivers:BKP 3.6.0, Device:StdPeriph Drivers:CRC 3.6.0, Device:StdPeriph Drivers:DBGMCU 3.6.0, Device:StdPeriph Drivers:DMA 3.6.0, Device:StdPeriph Drivers:EXTI 3.6.0, Device:StdPeriph Drivers:Flash 3.6.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:I2C 3.6.0, Device:StdPeriph Drivers:PWR 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:RTC 3.6.0, Device:StdPeriph Drivers:SPI 3.6.0, Device:StdPeriph Drivers:TIM 3.6.0, Device:StdPeriph Drivers:USART 3.6.0
